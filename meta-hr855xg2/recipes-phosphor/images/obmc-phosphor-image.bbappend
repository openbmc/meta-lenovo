# "Copyright (c) 2019-present Lenovo
# Licensed under BSD-3, see COPYING.BSD file for details."

OBMC_IMAGE_EXTRA_INSTALL_append_hr855xg2 = " pwr-button \
                                             lenovo-frus \
                                             lenovo-bmc-update \
                                             lenovo-bios-update \
                                           "
